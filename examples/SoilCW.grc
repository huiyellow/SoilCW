options:
  parameters:
    generate_options: qt_gui
    id: SoilCW_gui
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    value: 2**13
  states: {}
- name: cw_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: delta_f
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: main_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: num_drops
  id: variable
  parameters:
    value: 2**10
  states: {}
- name: pulse_amp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: recv_len
  id: variable
  parameters:
    value: burst_len+256
  states: {}
- name: ref_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: SoilCW_ChannelResponseExtractor_0
  id: SoilCW_ChannelResponseExtractor
  parameters:
    cable_length: '0.6'
    cable_speed_factor: '0.697'
    d_g: '0.05'
    d_m: '0.3'
    delta_f: int(delta_f)
    dir: /home/hui/gr-SoilCW/data
    f_c: int(main_freq)
    num_drops: num_drops
    recv_len: recv_len
  states: {}
- name: SoilCW_soil_cw_radar_cc_0
  id: SoilCW_soil_cw_radar_cc
  parameters:
    baseband_amp: pulse_amp
    baseband_freq: cw_freq
    burst_len: burst_len
    delta_f: int(delta_f)
    enable_biastee: 'False'
    main_freq: int(main_freq)
    recv_len: recv_len
    ref_gain: int(ref_gain)
    rx_gain: int(rx_gain)
    samp_rate: int(samp_rate)
    t_inc_send_ms: '10'
    tx_gain: int(tx_gain)
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: recv_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: recv_len
    type: complex
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: cw_freq*1.5
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: cw_freq/2
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: cw_freq*1.5
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: cw_freq/2
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '3'
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '3'
    srate: samp_rate
    type: float
    ylabel: Amp
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '2'
    size: recv_len*3
    srate: samp_rate
    type: complex
  states: {}
- name: scan_cont
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: ''
    type: int
    value: '2'
  states: {}
- name: scan_once
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: ''
    type: int
    value: '1'
  states: {}

connections:
- [SoilCW_ChannelResponseExtractor_0, '0', blocks_complex_to_magphase_0, '0']
- [SoilCW_soil_cw_radar_cc_0, '0', filter_fft_low_pass_filter_0, '0']
- [SoilCW_soil_cw_radar_cc_0, '1', filter_fft_low_pass_filter_0_0, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', SoilCW_ChannelResponseExtractor_0, '0']
- [blocks_stream_to_vector_0_0, '0', SoilCW_ChannelResponseExtractor_0, '1']
- [filter_fft_low_pass_filter_0, '0', blocks_stream_to_vector_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_time_sink_x_0_1, '0']
- [filter_fft_low_pass_filter_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [filter_fft_low_pass_filter_0_0, '0', qtgui_time_sink_x_0_1, '1']
- [scan_cont, pressed, SoilCW_soil_cw_radar_cc_0, scan]
- [scan_once, pressed, SoilCW_soil_cw_radar_cc_0, scan]

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
